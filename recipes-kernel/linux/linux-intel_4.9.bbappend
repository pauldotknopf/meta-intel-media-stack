FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
    file://i915_yv12_media_driver_bug.patch \
  "
